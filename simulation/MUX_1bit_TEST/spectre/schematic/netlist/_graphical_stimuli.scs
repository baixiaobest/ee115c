_vvdd! (vdd! 0) vsource dc=1.0 type=dc
